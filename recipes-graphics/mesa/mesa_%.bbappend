# Copyright (C) 2015 UCAS dengke.du
# Released under the MIT license (see COPYING.MIT for the terms)

#EXTRA_OEMESON:append = " -Dglx=dri "
#PACKAGECONFIG:append = " panfrost tools "
#PV = "25.0.2"
#SRC_URI[sha256sum] = "adf904d083b308df95898600ffed435f4b5c600d95fb6ec6d4c45638627fdc97"
