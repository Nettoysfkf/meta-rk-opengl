# Copyright (C) 2025 UCAS dengke.du
# Released under the MIT license (see COPYING.MIT for the terms)

# DEPENDS:append = " libxinerama"
# XSERVER_RDEPENDS:append = " libxinerama"
# PACKAGECONFIG:append = " xinerama"
